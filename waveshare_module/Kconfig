## waveshare_module/Kconfig
```kconfig
config WAVESHARE
tristate = "Driver for Waveshare e-paper display"
depends on ARM
default m
help
waveshare
```
